# Keil uVision project led_with_sw.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Microchip
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: led_with_sw +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: led_with_sw.c
